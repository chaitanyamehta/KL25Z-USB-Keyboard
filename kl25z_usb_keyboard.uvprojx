# Keil uVision project kl25z_usb_keyboard.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: kl25z_usb
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CLOCK_SETUP=4
  c include: ./include/
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group source
    ./src/: main.c led.c delay.c
  group usb
    ./src/: usb.c usb_descriptors.c
software components: CMSIS Driver:USB Device:Custom 2.2.0, CMSIS:CORE 5.3.0, Device:Startup 2.5.0
